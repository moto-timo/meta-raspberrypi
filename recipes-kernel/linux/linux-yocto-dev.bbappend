FILESEXTRAPATHS:prepend:raspberrypi5 := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE:raspberrypi5 = "${MACHINE}"
